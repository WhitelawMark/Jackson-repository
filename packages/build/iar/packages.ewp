# IAR project packages.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\packages\i2c-tools-latest\src; ..\..\packages\libcsv-v3.0.3; ..\..\packages\netutils-v1.2.0\iperf; ..\..\packages\netutils-v1.2.0\telnet; ..\..\packages\netutils-v1.2.0\tftp; ..\..\packages\netutils-v1.2.0\tcpdump; ..\..\packages\netutils-v1.2.0\ntp; ..\..\packages\netutils-v1.2.0\netio; ..\..\packages\optparse-v1.0.0; ..\..\packages\syswatch-latest\inc; ..\..\..\bsp\drivers\include; ..\..\..\os\rt_thread\include\; ..\..\..\os\rt_thread\include\libc; ..\..\..\os\rt_thread\components\cplusplus; ..\..\..\os\rt_thread\components\dfs\include; ..\..\..\os\rt_thread\components\dfs\filesystems\devfs; ..\..\..\os\rt_thread\components\dfs\filesystems\uffs; ..\..\..\os\rt_thread\components\dfs\filesystems\uffs\src\inc; ..\..\..\os\rt_thread\components\drivers\include\; ..\..\..\os\rt_thread\components\drivers\include\drivers; ..\..\..\os\rt_thread\components\drivers\include\ipc; ..\..\..\os\rt_thread\components\finsh; ..\..\..\os\rt_thread\components\libc\compilers\dlib; ..\..\..\os\rt_thread\components\libc\compilers\newlib\sys; ..\..\..\os\rt_thread\components\libc\compilers\common; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\arch\include; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\include; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\include\lwip; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\include\lwip\apps; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\include\lwip\priv; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\include\lwip\prot; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\include\netif; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\include\netif\ppp; ..\..\..\os\rt_thread\components\net\lwip-2.0.2\src\include\posix; ..\..\..\os\rt_thread\components\net\netdev\include; ..\..\..\os\rt_thread\components\net\netdev\include\arpa; ..\..\..\os\rt_thread\components\net\sal_socket\impl; ..\..\..\os\rt_thread\components\net\sal_socket\include; ..\..\..\os\rt_thread\components\net\sal_socket\include\dfs_net; ..\..\..\os\rt_thread\components\net\sal_socket\include\dfs_net\sys_select\sys; ..\..\..\os\rt_thread\components\net\sal_socket\include\socket\; ..\..\..\os\rt_thread\components\net\sal_socket\include\socket\netinet; ..\..\..\os\rt_thread\components\net\sal_socket\include\dfs_net\sys_select\; ..\..\..\os\rt_thread\components\net\sal_socket\include\socket\sys_socket\sys; ..\..\..\os\rt_thread\components\utilities\ulog; ..\..\..\os\rt_thread\components\utilities\ulog\backend; ..\..\..\os\rt_thread\components\utilities\ulog\syslog; ..\..\..\os\rt_thread\components\utilities\utest; ..\..\..\os\rt_thread\components\utilities\ymodem; ..\..\..\os\rt_thread\components\utilities\zmodem
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: packages.srec
  ILINK.IlinkOutputFile: packages.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group packages/i2c-tools-latest/src
    ../../packages/i2c-tools-latest/src/: i2c_tools.cpp i2c_utils.cpp i2c_utils.h SoftwareI2C.h
  group packages/libcsv-v3.0.3
    ../../packages/libcsv-v3.0.3/: libcsv.c libcsv.h
  group packages/netutils-v1.2.0/iperf
    ../../packages/netutils-v1.2.0/iperf/: iperf.c
  group packages/netutils-v1.2.0/telnet
    ../../packages/netutils-v1.2.0/telnet/: telnet.c
  group packages/netutils-v1.2.0/tftp
    ../../packages/netutils-v1.2.0/tftp/: tftp.h tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c tftp_xfer.h
  group packages/optparse-v1.0.0
    ../../packages/optparse-v1.0.0/: optparse.c optparse.h
  group packages/syswatch-latest/inc
    ../../packages/syswatch-latest/inc/: syswatch.h syswatch_config.h
  group packages/syswatch-latest/src
    ../../packages/syswatch-latest/src/: syswatch.c syswatch_test.c
