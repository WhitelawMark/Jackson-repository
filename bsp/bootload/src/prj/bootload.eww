<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\..\..\prj\aim3_prj.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\bootload.ewp</path>
    </project>
    <batchBuild />
</workspace>
