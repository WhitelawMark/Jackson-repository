/*******************************************************************************
**                                                                            **
**  文件名称:  Queue.c                                                        **
**  版权所有:  CopyRight @laiyisi(Xiamen) Technology Co., Ltd.2018            **
**  文件描述:  队列                                                           **
**  ========================================================================  **
**  创建信息:  | 2015-5-5 | lwp | 创建本模块                                  **
**  ========================================================================  **
**  修改信息:  单击此处添加....                                               **
*******************************************************************************/
#include "type.h" 
#include "Queue.h" 
/*******************************************************************************
**  函数名称:  InitQueue
**  功能描述:  初始化队列
**  输入参数:  无
**  输出参数:  无
**  返回参数:  无
*******************************************************************************/
void InitQueue(sqqueue* q, u8_t *buff)
{    
    q->base = buff;
    q->front = q->rear = 0;
} 
/*******************************************************************************
**  函数名称:  EnQueue
**  功能描述:  入队
**  输入参数:  无
**  输出参数:  无
**  返回参数:  无
*******************************************************************************/
u8_t EnQueue(sqqueue* q,u8_t e)
{
    if (((q->rear+1)%MAXQSIZE) == q->front){
        return 0;                                                    /* 队列满 */
    }

    if (q->rear == 917) {
          q->rear = 917;
    }
    q->base[q->rear]=e;
    q->rear=(q->rear+1)%MAXQSIZE;
    
    return 1;
} 
/*******************************************************************************
**  函数名称:  DeQueue
**  功能描述:  出队
**  输入参数:  无
**  输出参数:  无
**  返回参数:  无
*******************************************************************************/
u8_t DeQueue(sqqueue* q,u8_t* e)
{
    if(q->front == q->rear){
        return 0;
    }

    *e = q->base[q->front];
    q->front = (q->front+1)%MAXQSIZE;
    
    return 1;
}
